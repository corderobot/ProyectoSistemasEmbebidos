# Keil uVision project proyecto_17001922.uvprojx, settings and files
target K8 (6140000::V6.14::ARMCLANG)
  device: STM32F303K8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proyecto_17001922
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group files
    ./: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
